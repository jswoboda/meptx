options:
  parameters:
    author: John Swoboda
    generate_options: qt_gui
    id: drf2zmq
    output_language: python
    title: Digital RF to ZeroMQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: drfdir
  id: parameter
  parameters:
    label: drfdir
    type: str
    value: '""'
  states: {}
- name: en_time
  id: parameter
  parameters:
    label: en_time
    type: str
    value: '""'
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: drfdir
    end: en_time
    gapless: 'False'
    hide_msg_port: 'False'
    min_chunksize: '0'
    repeat: 'False'
    start: st_time
  states: {}
- name: l1pubaddr
  id: parameter
  parameters:
    label: l1pubaddr
    type: str
    value: '"tcp://127.0.0.1:5561"'
  states: {}
- name: st_time
  id: parameter
  parameters:
    label: st_time
    type: str
    value: '""'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: l1pubaddr
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, properties, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.7.0

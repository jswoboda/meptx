options:
  parameters:
    author: John Swoboda
    generate_options: qt_gui
    id: zmq_rec
    output_language: python
    title: ZMQ Receive
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: subaddr
  id: parameter
  parameters:
    label: subaddr
    type: str
    value: '"tcp://127.0.0.1:5561"'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: subaddr
    timeout: '100'
    type: short
    vlen: '2'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
